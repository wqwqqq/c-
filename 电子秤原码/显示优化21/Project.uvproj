# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H8K64U Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\LIB;.\USER;.\SYS
  group User
    ./USER/: main.c LED.c LED.h TM1668.c TM1668.h Key_s.c Key_s.h timer0.c timer0.h HX711.c HX711.h Scale.c Scale.h My_eeprom.c My_eeprom.h Buzzer.c Buzzer.h
  group SYS
    ./SYS/: delay.c config.h
  group Lib
    ./LIB/: ADC.c compare.c EEPROM.c Exti.c GPIO.c I2C.c PCA.c PWM.C PWM15bit.c Soft_UART.c spi.c timer.c UART.C WDT.c
